# Repository huanyu1999/UWB_Positioning_Terminal_Board (continued)

## KiCad design UWB_Positioning_Terminal.kicad_pcb (continued)

Parts:
C65, C73: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C66, C74: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J9: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
LS1, LS2: Speaker; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
R78, R79: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R80, R93: 210.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U8, U10: MAX98357AGTE_V+T; TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm_ThermalVias; Manufacturer_Part_Number MAX98357AGTE/V+T

Connections:
/Audio_Output/AUDIO_CHL_SEL: R80.2, R93.2; also elsewhere on the board
/Audio_Output/GANI_SEL: J9.1, J9.3, J9.5, J9.7, U8.2 (GAIN_SLOT), U10.2 (GAIN_SLOT)
/Audio_Output/SAI1_TX_BCLK: U8.16 (BCLK), U10.16 (BCLK); also elsewhere on the board
/Audio_Output/SAI1_TX_D0: U8.1 (DIN), U10.1 (DIN); also elsewhere on the board
/Audio_Output/SAI1_TX_SYNC: U8.14 (LRCLK), U10.14 (LRCLK); also elsewhere on the board
DCDC_5V: C65.1, C66.1, C73.1, C74.1, J9.6, R78.2, U8.7 (VDD_1), U8.8 (VDD_2), U10.7 (VDD_1), U10.8 (VDD_2); also elsewhere on the board
GND: C65.2, C66.2, C73.2, C74.2, J9.4, R79.1, U8.3 (GND_1), U8.11 (GND_2), U8.15 (GND_3), U8.17 (EP), U10.3 (GND_1), U10.11 (GND_2), U10.15 (GND_3), U10.17 (EP); also elsewhere on the board
unnamed: J9.2, R78.1
unnamed: J9.8, R79.2
unnamed: LS1.1, U8.10 (OUTN)
unnamed: LS1.2, U8.9 (OUTP)
unnamed: R80.1, U8.4 (~SD_MODE)
unnamed: LS2.1, U10.10 (OUTN)
unnamed: LS2.2, U10.9 (OUTP)
unnamed: R93.1, U10.4 (~SD_MODE)

Notes on the sheet:
GAIN_SLOT引脚选择功放增益
Aduio Output Stereo PCM
SD_MODE引脚上拉选择声道输出： R80为0R，左声道输出； R80为210.2K，右声道输出； R80为634K,左右对半输出； SD_MODE引脚下拉，关闭输出；
GAIN Select

Schematic: Power.kicad_sch

Parts:
BT1: BS-2450-3; BAT-TH_BS-24-A1AJ013
C2: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C11: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 22uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C6, C7: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 390pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C10: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C12: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C85: 33nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3: SMBJ6.5CA; D_SMB_Handsoldering
D4: PESD5V0L2BT-QR; SOT95P230X110-3N; Manufacturer_Part_Number PESD5V0L2BT-QR; Mouser Part Number 771-PESD5V0L2BT-QR
D5: LED; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D6: SMAJ30CA; D_SMA_Handsoldering
D15: BAV70; SOT-23
F1: JK-nSMD200/6V; Fuse_1206_3216Metric
F2: SMD1812-200/30N; Fuse_1812_4532Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: DC-044A-A200; DC-IN-TH_DC-044A-20A
L1: 10uH; L_APV_APH0630
Q1: AO3401A; TSOT-23_HandSoldering
R4: 4.7R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R9, R11: 100K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 53.6K; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R8: 845K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 22K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push_DPDT; SW-TH_5.8ZSGT
TP1: BASE_3V3_TP; PinHeader_1x01_P2.54mm_Vertical
TP2: MP9943_SW_TP; TestPoint_Pad_D1.5mm
TP3, TP15, TP16: GND_TP; PinHeader_1x01_P2.54mm_Vertical
TP4: TYPEC_5V_TP; TestPoint_Pad_D1.5mm
TP5: SYS_5V_TP; PinHeader_1x01_P2.54mm_Vertical
TP6: DCIN_24V_TP; TestPoint_Pad_D3.0mm
TP12: VBAT_TP; TestPoint_Pad_D1.5mm
U2: MP20051DQ-LF-Z; SON65P300X300X100-9N-D; Manufacturer_Part_Number MP20051DQ-LF-Z; Mouser Part Number 946-MP20051DQLFZ
U3: MP9447GL-P; MP9447GLP; Manufacturer_Part_Number MP9447GL-P; Mouser Part Number 946-MP9447GL-P

Connections:
/Power/LDO_EN: C11.1, R10.2, U2.5 (EN)
BASE_3V3: C4.1, D15.2 (A), R5.1, TP1.1 (1_1), U2.1 (OUT_1), U2.2 (OUT_2); also elsewhere on the board
COIN_BAT_3V3: D15.3 (K); also elsewhere on the board
DCDC_5V: C3.1, C8.2, C9.1, C10.1, D4.1 (K1), L1.2, Q1.3 (S), R7.1, R10.1, R13.1, R15.1, TP4.1 (1_1), TP5.1 (1_1), U2.7 (IN_1), U2.8 (IN_2); also elsewhere on the board
DCIN_24V: C5.1, C6.1, C7.1, D6.2 (A2), F2.2, R6.1, TP6.1 (1_1), U3.8 (IN_1), U3.19 (IN_2), U3.21 (IN_3), U3.22 (IN_4), U3.23 (IN_5)
GND: BT1.2 (-), C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C85.2, D3.1 (A1), D4.3 (COM_K), D5.1 (K), D6.1 (A1), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.2, J2.3, J2.MP (MountPin_MP), R9.2, R11.2, R12.2, R14.2, TP3.1 (1_1), TP15.1 (1_1), TP16.1 (1_1), U2.4 (GND), U2.9 (EP), U3.1 (AGND), U3.11 (PGND_1), U3.12 (PGND_2), U3.13 (PGND_3), U3.14 (PGND_4), U3.15 (PGND_5), U3.16 (PGND_6); also elsewhere on the board
unnamed: BT1.1 (+), D15.1 (A), TP12.1 (1_1)
unnamed: C2.1, R4.2
unnamed: D3.2 (A2), F1.2, Q1.1 (D)
unnamed: D4.2 (K2), Q1.2 (G), R13.2, R14.1
unnamed: D5.2 (A), R15.2
unnamed: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: F2.1, SW1.3 (C), SW1.6 (C)
unnamed: J2.1, SW1.2 (B), SW1.5 (B)
unnamed: R5.2, R9.1, U2.3 (FB)
unnamed: R4.1, U3.7 (BST)
unnamed: R6.2, U3.5 (EN)
unnamed: C8.1, R7.2, R8.2, R12.1, U3.3 (FB)
unnamed: R11.1, U3.2 (FREQ)
unnamed: C85.1, U3.4 (SS)
unnamed: C2.2, L1.1, R8.1, TP2.1 (1_1), U3.9 (SW_1), U3.10 (SW_2), U3.17 (SW_3), U3.18 (SW_4), U3.24 (SW_5), U3.25 (SW_6)
unnamed: C12.1, U3.20 (VCC)

Notes on the sheet:
5V Power LED
Power Interface
External DC_24V convert to 5V
BAT For RT1052_SNVS Power
自锁电源开关
高边防反接电路，单PMOS
MHCB06030-100M-C1
5V convert to 3.3V,for base board's chip
RC延时电路， 目的在于让底板的3.3V电压晚于核心板的SYS_5V电源上电, 以免底板IO设备电源倒灌损伤MCU， 可调整参数

Schematic: LCD.kicad_sch

Parts:
C13, C14, C15, C16: 330nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C17: 220nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18: 1nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19: 2.2nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20, C34: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C21, C22: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C23, C25, C33: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C24, C31: 22pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C26, C27, C28, C29: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C30, C32: 22uF; C_Elec_6.3x5.8
C35: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C36: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C37: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D7, D8: BAT54S; SOT-23
D9, D10: SS34; D_SMA
J10: Conn_01x50_MountingPin; FPC-SMD_FH12A-50S-0.5SH-55-1
L2: CBG160808U121T; L_0201_0603Metric_Pad0.64x0.40mm_HandSolder
L3: 3.9uH; L_Cenker_CKCS6028
L4: 4.7uH; L_Changjiang_FTC252010S
R16: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 511K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18: 402K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19: 104K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 24K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21: 100K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R22: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R23: 620K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24: 75K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25, R27, R29: 4.7K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R26, R28, R30: 4.7K_NC; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R31: 33R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R32, R33: 3R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R34, R35: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1, RN2, RN3, RN4, RN5: 22R X 4; R_Array_Concave_4x0603
TP7: LCD_VGL_TP; TestPoint_Pad_D1.5mm
TP8: LCD_VGH_TP; TestPoint_Pad_D1.5mm
TP9: LCD_VCOM_TP; TestPoint_Pad_D1.5mm
TP10: LCD_VDDA_TP; TestPoint_Pad_D1.5mm
TP14: LCD_CLK_TP; TestPoint_Pad_D1.0mm
U4: TPS65150RGERG4; Texas_RGE0024H_VQFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_Thermal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; Manufacturer_Part_Number TPS65150RGERG4; Mouser Part Number 595-TPS65150RGERG4
U5: MP3302DJ-LF-P; TSOT-23-5_HandSoldering; Manufacturer_Part_Number MP3302DJ-LF-P; Mouser Part Number 946-MP3302DJLFP

Connections:
/LCD/BLK: R34.1, R35.2; also elsewhere on the board
/LCD/DCLK: C29.1, J10.14, L2.2
/LCD/DE: C28.1, J10.42, RN5.4 (R4.1)
/LCD/HSYNC: C26.1, J10.40, RN5.2 (R2.1)
/LCD/LCDIF_CLK: RN4.8 (R1.2), TP14.1 (1_1); also elsewhere on the board
/LCD/LCDIF_D0: RN1.8 (R1.2); also elsewhere on the board
/LCD/LCDIF_D1: RN1.7 (R2.2); also elsewhere on the board
/LCD/LCDIF_D2: RN1.6 (R3.2); also elsewhere on the board
/LCD/LCDIF_D3: RN1.5 (R4.2); also elsewhere on the board
/LCD/LCDIF_D4: RN5.8 (R1.2); also elsewhere on the board
/LCD/LCDIF_D5: RN2.6 (R3.2); also elsewhere on the board
/LCD/LCDIF_D6: RN2.5 (R4.2); also elsewhere on the board
/LCD/LCDIF_D7: RN3.8 (R1.2); also elsewhere on the board
/LCD/LCDIF_D8: RN3.7 (R2.2); also elsewhere on the board
/LCD/LCDIF_D9: RN3.6 (R3.2); also elsewhere on the board
/LCD/LCDIF_D10: RN3.5 (R4.2); also elsewhere on the board
/LCD/LCDIF_D11: RN4.7 (R2.2); also elsewhere on the board
/LCD/LCDIF_D12: RN4.6 (R3.2); also elsewhere on the board
/LCD/LCDIF_D13: RN4.5 (R4.2); also elsewhere on the board
/LCD/LCDIF_D14: RN2.8 (R1.2); also elsewhere on the board
/LCD/LCDIF_D15: RN2.7 (R2.2); also elsewhere on the board
/LCD/LCDIF_ENABLE: RN5.5 (R4.2); also elsewhere on the board
/LCD/LCDIF_HSYNC: RN5.7 (R2.2); also elsewhere on the board
/LCD/LCDIF_VSYNC: RN5.6 (R3.2); also elsewhere on the board
/LCD/LCD_B0: J10.35, RN1.1 (R1.1)
/LCD/LCD_B1: J10.36, RN1.2 (R2.1)
/LCD/LCD_B2: J10.37, RN1.3 (R3.1)
/LCD/LCD_B3: J10.38, RN1.4 (R4.1)
/LCD/LCD_B4: J10.39, RN5.1 (R1.1)
/LCD/LCD_G0: J10.26, RN2.3 (R3.1)
/LCD/LCD_G1: J10.27, RN2.4 (R4.1)
/LCD/LCD_G2: J10.28, RN3.1 (R1.1)
/LCD/LCD_G3: J10.29, RN3.2 (R2.1)
/LCD/LCD_G4: J10.30, RN3.3 (R3.1)
/LCD/LCD_G5: J10.31, RN3.4 (R4.1)
/LCD/LCD_R0: J10.19, RN4.2 (R2.1)
/LCD/LCD_R1: J10.20, RN4.3 (R3.1)
/LCD/LCD_R2: J10.21, RN4.4 (R4.1)
/LCD/LCD_R3: J10.22, RN2.1 (R1.1)
/LCD/LCD_R4: J10.23, RN2.2 (R2.1)
/LCD/LED_A: C35.1, D10.1 (K), J10.49, J10.50
/LCD/LED_K: J10.47, J10.48, R32.2, R33.2, U5.3 (FB)
/LCD/L/R: J10.12, R25.2, R28.1
/LCD/MODE: J10.43, R27.2, R30.1
/LCD/RESET: J10.7; also elsewhere on the board
/LCD/U/D: J10.11, R26.2, R29.1
/LCD/VSYNC: C27.1, J10.41, RN5.3 (R3.1)
BASE_3V3: C33.1, C34.1, J10.44, R25.1, R26.1, R27.1; also elsewhere on the board
DCDC_5V: C20.1, C30.1, C36.1, L3.1, L4.1, R31.2, U4.7 (VIN), U4.16 (CTRL); also elsewhere on the board
GND: C13.2, C14.2, C17.2, C18.2, C19.2, C21.1, C22.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, D7.2 (K), J10.3, J10.4, J10.13, J10.15, J10.16, J10.17, J10.18, J10.24, J10.25, J10.32, J10.33, J10.34, J10.46, J10.MP (MountPin), R21.2, R22.2, R24.2, R28.2, R29.2, R30.2, R32.1, R33.1, R35.1, U4.10 (PGND_1), U4.11 (PGND_2), U4.22 (GND), U4.25 (EP), U5.2 (GND); also elsewhere on the board
unnamed: C15.1, D7.3 (COM)
unnamed: C16.1, D8.3 (COM)
unnamed: C14.1, D8.2 (K), R16.1, U4.19 (CPI)
unnamed: D9.2 (A), L3.2, U4.8 (SW_1), U4.9 (SW_2)
unnamed: D10.2 (A), L4.2, U5.1 (SW)
unnamed: R16.2, R18.1
unnamed: L2.1, RN4.1 (R1.1)
unnamed: C24.1, U4.17 (ADJ)
unnamed: C19.1, U4.1 (COMP)
unnamed: C21.2, U4.5 (DLY1)
unnamed: C22.2, U4.6 (DLY2)
unnamed: C15.2, U4.21 (DRVN)
unnamed: C16.2, U4.20 (DRVP)
unnamed: C31.2, R23.2, R24.1, U4.4 (FB)
unnamed: R17.2, R19.1, U4.24 (FBN)
unnamed: R18.2, R21.1, U4.15 (FBP)
unnamed: C20.2, U4.3 (FDLY)
unnamed: C18.1, R20.1, R22.1, U4.14 (IN)
unnamed: C17.1, R19.2, U4.23 (REF)
unnamed: R34.2, U5.4 (EN)
unnamed: C37.1, R31.1, U5.5 (IN)
VCOM: C23.1, J10.5, J10.45, TP9.1 (1_1), U4.13 (VCOM)
VDD_A: C25.1, C31.1, C32.1, D8.1 (A), D9.1 (K), J10.8, R20.2, R23.1, TP10.1 (1_1), U4.12 (SUP)
VGH: J10.10, TP8.1 (1_1), U4.18 (VGH)
VGL: C13.1, D7.1 (A), J10.9, R17.1, TP7.1 (1_1)

Notes on the sheet:
VDD_A输出10.6V R1 取620K R2 取75K（51K + 24K）
LCD Back_Light Driver
SS54
10寸LCD引脚参照
C17一定要靠近U3的PIN-5放置
LCD_Driver, provide VGH VGL VDDA VCOM
ASPI-0628-3R9M-T1
VGL 输出-5.96V R1 取511K R2 取104K
FPC线序对比参照引脚需要翻转，因为FPC端子位于屏幕后方
VGH 输出18.23V R1 取1402K R2 取100K

Board: 4 copper layers, 200.0 x 140.5 mm, 252 parts (0 on the bottom side), 196 nets.
