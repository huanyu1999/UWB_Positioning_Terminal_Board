# Repository huanyu1999/UWB_Positioning_Terminal_Board

## KiCad design UWB_Positioning_Terminal.kicad_pcb

Parts:
BUZZER1: FST-5020; BUZ-SMD_FST-5020; MPN FUET-5020; LCSC Part C391029
C67, C68, C69, C70, C71, C72: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D16: 1N4148; D_SOD-123
Q3: S8050; SOT-23_Handsoldering
R81, R83, R85, R87, R89: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R82, R84, R86, R88, R90: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R91, R92: 4.7K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW3, SW4, SW5, SW6, SW7: SW_Push_Dual; SW-TH_4P-L6.0-W6.0-P4.50-LS6.5

Connections:
/Button_And_Buzzer/BUZZER: R91.1; also elsewhere on the board
/Button_And_Buzzer/USER_SW0: C70.1, R87.1; also elsewhere on the board
/Button_And_Buzzer/USER_SW1: C67.1, R81.1; also elsewhere on the board
/Button_And_Buzzer/USER_SW2: C68.1, R83.1; also elsewhere on the board
/Button_And_Buzzer/USER_SW3: C71.1, R89.1; also elsewhere on the board
/Button_And_Buzzer/USER_SW4: C69.1, R85.1; also elsewhere on the board
BASE_3V3: BUZZER1.1 (+), C72.1, D16.1 (K), R82.2, R84.2, R86.2, R88.2, R90.2; also elsewhere on the board
GND: C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, D16.2 (A), Q3.1 (E), R92.1, SW3.3, SW3.4, SW4.3, SW4.4, SW5.3, SW5.4, SW6.3, SW6.4, SW7.3, SW7.4; also elsewhere on the board
unnamed: Q3.2 (B), R91.2, R92.2
unnamed: BUZZER1.2, Q3.3 (C)
unnamed: R81.2, R82.1, SW3.1, SW3.2
unnamed: R83.2, R84.1, SW4.1, SW4.2
unnamed: R85.2, R86.1, SW5.1, SW5.2
unnamed: R87.2, R88.1, SW6.1, SW6.2
unnamed: R89.2, R90.1, SW7.1, SW7.2

Notes on the sheet:
Button_And_Buzzer

Parts:
C38, C41: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C39, C40, C44, C46, C47, C48, C50: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C42, C45: 100nF_NC; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C43: 2.2uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C49: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D12: 1N4148; D_SOD-123
J5: RJ45_Hanrun_HR911105A_Horizontal; RJ45-TH_HR911105A
L6: 120 Ohm @100MHz BLM18PG121SN1D; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R39, R40, R41, R42: 49.9R_NC; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R43, R44, R45, R46, R47, R48, R94: 33R; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R49, R52: 220R; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R50, R51: 4.7K; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R53, R54: 1K; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R55: 6.49K; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R56: 10K; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R57: 0R; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
TP11: ENET_CLK_TP; TestPoint_Pad_D1.0mm
U7: KSZ8081RND; QFN-24-1EP_4x4mm_P0.5mm_EP2.65x2.65mm_ThermalVias
Y1: OT1EL89CJI-111YLC-50M; Oscillator_SMD_SeikoEpson_SG8002LB-4Pin_5.0x3.2mm_HandSolde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

Connections:
/Ethernet/ENET_CLK: R94.2; also elsewhere on the board
/Ethernet/ENET_CRS_DV: R48.1; also elsewhere on the board
/Ethernet/ENET_INT: R53.2, U7.18 (INTRP); also elsewhere on the board
/Ethernet/ENET_LED_CTRL: J5.10, J5.11, R50.2, R51.2, U7.23 (LED0/ANEN_SPEED)
/Ethernet/ENET_MDC: U7.11 (MDC); also elsewhere on the board
/Ethernet/ENET_MDIO: R54.2, U7.10 (MDIO); also elsewhere on the board
/Ethernet/ENET_RST: C48.1, D12.2 (A), R56.2, U7.24 (~RST); also elsewhere on the board
/Ethernet/ENET_RXD0: R46.1; also elsewhere on the board
/Ethernet/ENET_RXD1: R47.1; also elsewhere on the board
/Ethernet/ENET_RXER: U7.17 (RXER); also elsewhere on the board
/Ethernet/ENET_RX_N: J5.3 (RD+), R41.2, U7.3 (RXM)
/Ethernet/ENET_RX_P: J5.6 (RD-), R42.2, U7.4 (RXP)
/Ethernet/ENET_TXD0: R44.1; also elsewhere on the board
/Ethernet/ENET_TXD1: R45.1; also elsewhere on the board
/Ethernet/ENET_TXEN: R43.1; also elsewhere on the board
/Ethernet/ENET_TX_N: J5.1 (TD+), R40.2, U7.5 (TXM)
/Ethernet/ENET_TX_P: J5.2 (TD-), R39.2, U7.6 (TXP)
BASE_3V3: C40.1, C41.1, C42.1, C45.1, C49.1, C50.1, D12.1 (K), L6.1, R39.1, R40.1, R41.1, R42.1, R49.1, R50.1, R51.1, R52.1, R53.1, R54.1, R56.1, R57.1, U7.14 (VDDIO), Y1.4 (VCC); also elsewhere on the board
GND: C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, J5.8, J5.SH, R55.2, U7.22 (GND), U7.25 (GND), Y1.2 (GND); also elsewhere on the board
unnamed: J5.9, R52.2
unnamed: J5.12, R49.2
unnamed: C47.1, J5.5 (RCT)
unnamed: C46.1, J5.4 (TCT)
unnamed: R48.2, U7.15 (CRS_DV/PHYAD[1:0])
unnamed: R55.1, U7.9 (REXT)
unnamed: R46.2, U7.13 (RXD0)
unnamed: R47.2, U7.12 (RXD1)
unnamed: R44.2, U7.20 (TXD0)
unnamed: R45.2, U7.21 (TXD1)
unnamed: R43.2, U7.19 (TXEN)
unnamed: C38.1, C39.1, L6.2, U7.2 (VDDA_3.3)
unnamed: C43.1, C44.1, U7.1 (VDD_1.2)
unnamed: R94.1, TP11.1 (1_1), U7.8 (XI), Y1.3 (OUT)
unnamed: R57.2, Y1.1 (~ST)

Notes on the sheet:
Ethernet

Parts:
C51, C52: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D13: MBR0520LT; D_SOD-123
D14: PESD5V0L2BT-QR; SOT95P230X110-3N; Manufacturer_Part_Number PESD5V0L2BT-QR; Mouser Part Number 771-PESD5V0L2BT-QR
J6: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical
J7: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J8: DEBUG_UART; PinHeader_1x02_P2.54mm_Vertical
Q2: S8050; SOT-23_Handsoldering
R58: 0R_NC; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R59: 10K; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R60, R65, R68, R69: 22R; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R61, R64, R66, R67, R70: 10K; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R62, R63: 1K; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
SW2: SW_Push_Dual; SW-TH_4P-L6.0-W6.0-P4.50-LS6.5

Connections:
/Boot_Reset_SWD_UART/BOOT_MODE0: R68.1; also elsewhere on the board
/Boot_Reset_SWD_UART/BOOT_MODE1: R65.2; also elsewhere on the board
/Boot_Reset_SWD_UART/BOOT_MODE_CTRL: J7.6, R68.2, R69.2, R70.1
/Boot_Reset_SWD_UART/DEBUG_UART_RX: J8.2, R67.2; also elsewhere on the board
/Boot_Reset_SWD_UART/DEBUG_UART_TX: J8.1, R66.2; also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_MOD: R61.1; also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_TCK/SWCLK: J6.4 (SWCLK/TCK); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_TDI: J6.8 (NC/TDI); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_TDO: J6.6 (SWO/TDO); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_TMS/SWDIO: J6.2 (SWDIO/TMS); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_nTRST: C52.1, J6.10 (~RESET), R59.1, R60.2; also elsewhere on the board
/Boot_Reset_SWD_UART/WDG_EN: J7.8; also elsewhere on the board
/LCD/LCDIF_D5: J7.4; also elsewhere on the board
/LCD/LCDIF_D6: J7.2; also elsewhere on the board
BASE_3V3: D13.2 (A), J7.5, R58.1, R59.2, R62.2, R63.2, R64.1, R66.1, R67.1; also elsewhere on the board
GND: C51.1, C52.2, D14.3 (COM_K), J6.3 (GND), J6.5 (GND), J6.9 (GNDDetect), J7.7, Q2.1 (E), R61.2, R70.2, SW2.1, SW2.2; also elsewhere on the board
unnamed: D13.1 (K), J6.1 (VTref), R58.2
unnamed: C51.2, D14.1 (K1), D14.2 (K2), R60.1, SW2.3, SW2.4
unnamed: J7.1, R63.1
unnamed: J7.3, R62.1
unnamed: Q2.2 (B), R69.1
unnamed: Q2.3 (C), R64.2, R65.1

Notes on the sheet:
Boot
Reset
JTAG
DEBUG_UART
J8跳线端子配置详情： 1.NOR Flash 启动：断开BOOT_CFG6 (J8-pin1 J8-pin2), 断开BOOT_CFG5 (J8-pin3 J8-pin4)； 2.SD Card 启动：短接BOOT_CFG6 (J8-pin1 J8-pin2), 断开BOOT_CFG5 (J8-pin3 J8-pin4)； 3.NAND Flash 启动：断开BOOT_CFG6 (J8-pin1 J8-pin2), 短接BOOT_CFG5 (J8-pin3 J8-pin4)； 4.BOOT模式控制，内部启动：短接(J8-pin5 J8-pin6)，串行下载：断开(J8-pin5 J8-pi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

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via

Connections:
GND: H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1); also elsewhere on the board

Notes on the sheet:
Mounting hole

Parts:
C1: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: WS2812B-2020; LED_RGB_1210
D2: RUN_LED,Green; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
IC1: SN74AHCT1G125DCK3; SOT65P210X110-5N; Manufacturer_Part_Number SN74AHCT1G125DCK3; Mouser Part Number 595-74AHCT1G125DCK3
R1: 220R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 33R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 0R_NC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: M1052-16F128AWI-T

Connections:
/Audio_Output/AUDIO_CHL_SEL: U1.B53 (LPUART8_RX); also elsewhere on the board
/Audio_Output/SAI1_TX_BCLK: U1.B61 (LPSPI3_SDO); also elsewhere on the board
/Audio_Output/SAI1_TX_D0: U1.B67 (LPSPI3_SDI); also elsewhere on the board
/Audio_Output/SAI1_TX_SYNC: U1.B65 (LPSPI3_SCK); also elsewhere on the board
/Boot_Reset_SWD_UART/BOOT_MODE0: U1.A57 (BOOT_MODE0); also elsewhere on the board
/Boot_Reset_SWD_UART/BOOT_MODE1: U1.A59 (BOOT_MODE1); also elsewhere on the board
/Boot_Reset_SWD_UART/DEBUG_UART_RX: U1.B38 (LPUART1_RX); also elsewhere on the board
/Boot_Reset_SWD_UART/DEBUG_UART_TX: U1.B40 (LPUART1_TX); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_MOD: U1.B43 (JTAG_MOD); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_TCK/SWCLK: U1.B35 (JTAG_TCK); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_TDI: U1.B37 (JTAG_TDI); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_TDO: U1.B41 (JTAG_TDO); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_TMS/SWDIO: U1.B33 (JTAG_TMS); also elsewhere on the board
/Boot_Reset_SWD_UART/JTAG_nTRST: U1.A55 (nRST_IN), U1.B39 (JTAG_TRSTB); also elsewhere on the board
/Boot_Reset_SWD_UART/WDG_EN: U1.A40 (WDO_EN); also elsewhere on the board
/Button_And_Buzzer/BUZZER: U1.B72 (USDHC2_DATA3); also elsewhere on the board
/Button_And_Buzzer/USER_SW0: U1.B62 (USDHC2_CMD); also elsewhere on the board
/Button_And_Buzzer/USER_SW1: U1.B64 (USDHC2_CLK); also elsewhere on the board
/Button_And_Buzzer/USER_SW2: U1.B66 (USDHC2_DATA0); also elsewhere on the board
/Button_And_Buzzer/USER_SW3: U1.B68 (USDHC2_DATA1); also elsewhere on the board
/Button_And_Buzzer/USER_SW4: U1.B70 (USDHC2_DATA2); also elsewhere on the board
/EMMC/EMMC_CLK: U1.A54 (SD1_CLK); also elsewhere on the board
/EMMC/EMMC_CMD: U1.A56 (SD1_CMD); also elsewhere on the board
/EMMC/EMMC_D0: U1.A52 (SD1_D0); also elsewhere on the board
/EMMC/EMMC_D1: U1.A50 (SD1_D1); also elsewhere on the board
/EMMC/EMMC_D2: U1.A48 (SD1_D2); also elsewhere on the board
/EMMC/EMMC_D3: U1.A46 (SD1_D3); also elsewhere on the board
/EMMC/EMMC_RST: U1.B45 (LPUART3_CTS_B); also elsewhere on the board
/Ethernet/ENET_CLK: U1.B29 (ENET_TX_CLK); also elsewhere on the board
/Ethernet/ENET_CRS_DV: U1.B25 (ENET_RX_EN); also elsewhere on the board
/Ethernet/ENET_INT: U1.B34 (LPI2C1_SCL); also elsewhere on the board
/Ethernet/ENET_MDC: U1.B31 (ENET_MDC); also elsewhere on the board
/Ethernet/ENET_MDIO: U1.B32 (ENET_MDIO); also elsewhere on the board
/Ethernet/ENET_RST: U1.B36 (LPI2C1_SDA); also elsewhere on the board
/Ethernet/ENET_RXD0: U1.B23 (ENET_RX_DATA0); also elsewhere on the board
/Ethernet/ENET_RXD1: U1.B24 (ENET_RX_DATA1); also elsewhere on the board
/Ethernet/ENET_RXER: U1.B30 (ENET_RX_ER); also elsewhere on the board
/Ethernet/ENET_TXD0: U1.B26 (ENET_TX_DATA0); also elsewhere on the board
/Ethernet/ENET_TXD1: U1.B27 (ENET_TX_DATA1); also elsewhere on the board
/Ethernet/ENET_TXEN: U1.B28 (ENET_TX_EN); also elsewhere on the board
/LCD/BLK: U1.B55 (FLEXCAN1_TX); also elsewhere on the board
/LCD/LCDIF_CLK: U1.B2 (LCD_CLK); also elsewhere on the board
/LCD/LCDIF_D0: U1.B5 (LCD_DATA0); also elsewhere on the board
/LCD/LCDIF_D1: U1.B6 (LCD_DATA1); also elsewhere on the board
/LCD/LCDIF_D2: U1.B7 (LCD_DATA2); also elsewhere on the board
/LCD/LCDIF_D3: U1.B8 (LCD_DATA3); also elsewhere on the board
/LCD/LCDIF_D4: U1.B9 (LCD_DATA4); also elsewhere on the board
/LCD/LCDIF_D5: U1.B10 (LCD_DATA5); also elsewhere on the board
/LCD/LCDIF_D6: U1.B11 (LCD_DATA6); also elsewhere on the board
/LCD/LCDIF_D7: U1.B12 (LCD_DATA7); also elsewhere on the board
/LCD/LCDIF_D8: U1.B13 (LCD_DATA8); also elsewhere on the board
/LCD/LCDIF_D9: U1.B14 (LCD_DATA9); also elsewhere on the board
/LCD/LCDIF_D10: U1.B15 (LCD_DATA10); also elsewhere on the board
/LCD/LCDIF_D11: U1.B16 (LCD_DATA11); also elsewhere on the board
/LCD/LCDIF_D12: U1.B17 (LCD_DATA12); also elsewhere on the board
/LCD/LCDIF_D13: U1.B18 (LCD_DATA13); also elsewhere on the board
/LCD/LCDIF_D14: U1.B19 (LCD_DATA14); also elsewhere on the board
/LCD/LCDIF_D15: U1.B20 (LCD_DATA15); also elsewhere on the board
/LCD/LCDIF_ENABLE: U1.B1 (LCD_ENABLE); also elsewhere on the board
/LCD/LCDIF_HSYNC: U1.B3 (LCD_HSYNC); also elsewhere on the board
/LCD/LCDIF_VSYNC: U1.B4 (LCD_VSYNC); also elsewhere on the board
/LCD/RESET: U1.B49 (LPUART5_RX); also elsewhere on the board
/RT1052_Core/RUN_LED: R1.1, U1.B47 (LPUART3_RX)
/RT1052_Core/USB_OTG1_DN: U1.B73 (USB_OTG1_DN); also elsewhere on the board
/RT1052_Core/USB_OTG1_DP: U1.B75 (USB_OTG1_DP); also elsewhere on the board
/RT1052_Core/WS2812: R3.1, U1.B51 (LPUART6_RX)
COIN_BAT_3V3: U1.A4 (VDD_SNVS_BAT); also elsewhere on the board
DCDC_5V: C1.1, D1.4 (VDD), IC1.5 (VCC), U1.A1 (5V_SYS), U1.A3 (5V_SYS); also elsewhere on the board
GND: C1.2, D1.2 (VSS), D2.1 (K), IC1.1 (~OE), IC1.3 (GND), U1.A2 (GND), U1.A21 (GND), U1.A22 (GND), U1.A39 (GND), U1.A44 (GND), U1.B21 (GND), U1.B22 (GND), U1.B59 (GND), U1.B60 (GND), U1.B79 (GND); also elsewhere on the board
unnamed: D1.3 (DIN), R2.2
unnamed: D2.2 (A), R1.2
unnamed: IC1.2 (A), R3.2
unnamed: IC1.4 (Y), R2.1
USB_OTG1_VBUS: U1.B69 (USB_OTG1_VBUS); also elsewhere on the board

Notes on the sheet:
Indication LED
RT1052_CoreBoard_A
RT1052_CoreBoard_B

Parts:
C53, C54, C55, C56, C59, C60, C61, C62, C63: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C57, C64: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C58: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R71, R72, R73, R74, R76, R77: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R75: 22R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U9: KLM8G1GETF-B0410; LFBGA-153_11.5x13mm_Layout14x14_P0.5mm; Manufacturer_Part_Number KLM8G1GETF-B0410

Connections:
/EMMC/EMMC_CLK: R75.1; also elsewhere on the board
/EMMC/EMMC_CMD: R76.1, U9.M5 (CMD); also elsewhere on the board
/EMMC/EMMC_D0: R74.2, U9.A3 (DAT0); also elsewhere on the board
/EMMC/EMMC_D1: R71.2, U9.A4 (DAT1); also elsewhere on the board
/EMMC/EMMC_D2: R72.2, U9.A5 (DAT2); also elsewhere on the board
/EMMC/EMMC_D3: R73.2, U9.B1 (NC_10), U9.B2 (DAT3); also elsewhere on the board
/EMMC/EMMC_RST: R77.1, U9.K5 (RSTN); also elsewhere on the board
/EMMC/EMMC_VDDI: C58.1, U9.C1 (NC_19), U9.C2 (VDDI)
/EMMC/Net-(U9A-CLK): R75.2, U9.M6 (CLK)
BASE_3V3: C53.1, C54.1, C55.1, C56.1, C57.1, C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, R71.1, R72.1, R73.1, R74.1, R76.2, R77.2, U9.C6 (VDD_1), U9.E6 (VDDF_1), U9.F5 (VDDF_2), U9.J10 (VDDF_3), U9.K9 (VDDF_4), U9.M4 (VDD_2), U9.N4 (VDD_3), U9.P3 (VDD_4), U9.P5 (VDD_5); also elsewhere on the board
GND: C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, U9.A6 (VSS_1), U9.C4 (VSS_2), U9.C5 (NC_21), U9.E7 (VSS_3), U9.G5 (VSS_4), U9.H10 (VSS_5), U9.J5 (VSS_6), U9.K8 (VSS_7), U9.N2 (VSS_8), U9.N5 (VSS_9), U9.N6 (NC_91), U9.P2 (NC_101), U9.P4 (VSS_10), U9.P6 (VSS_11); also elsewhere on the board

Notes on the sheet:
8G EMMC

Parts:
D11: MBR0520LT; D_SOD-123
FL1: DLW21SN900SQ2L; DLW21SN121HQ2L
J4: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
L5: 600 Ohm @ 100MHz,MPZ2012S601AT000; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
R36, R37: 5.1K; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U6: USBLC6-2SC6; SOT-23-6

Connections:
/RT1052_Core/USB_OTG1_DN: FL1.3; also elsewhere on the board
/RT1052_Core/USB_OTG1_DP: FL1.1; also elsewhere on the board
/USB/USB_DEVICE_N: J4.A7 (D-), J4.B7 (D-), U6.1 (I/O1)
/USB/USB_DEVICE_P: J4.A6 (D+), J4.B6 (D+), U6.3 (I/O2)
GND: J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.SH (SHIELD), R36.1, R37.2, U6.2 (GND); also elsewhere on the board
unnamed: FL1.2, U6.4 (I/O2)
unnamed: FL1.4, U6.6 (I/O1)
unnamed: J4.A5 (CC1), R36.2
unnamed: J4.B5 (CC2), R37.1
unnamed: J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), L5.1
USB_OTG1_VBUS: D11.1 (K); also elsewhere on the board
VBUS_DEVICE: D11.2 (A), L5.2, U6.5 (VBUS)

Notes on the sheet:
USB_OTG1_DEVICE
